CORE_IMAGE_EXTRA_INSTALL:append = " \
    packagegroup-pixelatedrailroad-common \
    "